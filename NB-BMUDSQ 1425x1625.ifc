Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-06-02T09:26:50+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.10.18 - Exporter 23.0.10.18 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, Port_1724658
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_steel wheather wall louvre bmu intake LT_sacs:BMUDSQ, NLRS_57_AIR_UN_steel wheather wall louvre bmu intake LT_sacs:BMUDSQ:1724658
In: Default
Type - Description: Solid Air weather louvre BMU (air intake); Classification: 57.0 (Uniformat); Material: NLRS_57_sendzimir verzinkt_gen_sacs
Type - Constraints - Default Elevation: 0 mm
Type - General - LookupTable: BMU
Type - Identity Data - Assembly Code: 57.0; Description: Solid Air weather louvre BMU (air intake); Manufacturer: Solid Air Climate Systems; Model: Weather louvre; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 12-04-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.18.01; NLRS_C_niveau ontwikkeling: LOD 400; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Name: BMUDSQ; URL: https://solid-air.nl/producten/buitenluchtroosters-en-dakkappen/buitenluchtroosters/bmu
Type - Materials and Finishes - SACS_Material_Frame: Hot dip galvanised steel; SACS_Material_Wire_mesh: 2x2 stainless steel
Type - Mechanical - Flow - Max Flow: 0 m3/s; Min Flow: 0 m3/s
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_steel wheather wall louvre bmu intake LT_sacs; SACS_Base_Index: 6
Type - Visibility - SACS_Show_Symbol: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Systems
Type - Pset_ProductRequirements - Category: Air Terminals
Pset_DistributionFlowElementCommon - Reference: BMUDSQ; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 12.3646 m2; NLRS_M_c01_breedte: 1425 mm; NLRS_M_c01_hoogte: 1625 mm; SACS_Allow_custom_size: no; SACS_Height: 1625 mm; SACS_Size_check: Standard size; SACS_Width: 1425 mm; Volume: 0.00928827 m3
Identity Data - Mark: 7341; NLRS_C_description: Solid Air weather louvre BMU (air intake); NLRS_C_materiaal_kleur: no color treatment; NLRS_C_model: BMUDSQ 1425x1625; SACS_Article_Code: NB; SACS_Gross_Cost: 1156; SACS_Price_Date: 1-04-2021
Materials and Finishes - SACS_Face_Color: NLRS_57_sendzimir verzinkt_gen_sacs
Mechanical - SACS_Max_Lp_dBA: 45; SACS_Max_Ploss: 100 Pa; System Classification: Supply Air
Mechanical - Flow - Flow: 0 m3/s; NLRS_M_c01_debiet: 0 m3/s; SACS_Lp_dBA: 0; SACS_Total_Pressure_Loss: 0 Pa
Model Properties - SACS_Air_Velocity: 0 m/s; SACS_Color_Ral: no; SACS_Free_Area: 0.7375 m2; SACS_Option_1: Flange 54mm, door mount; SACS_Option_2: Stainless steel wire mesh; SACS_Option_3: Door mount; SACS_Standard_Color: yes; SACS_Wall_Thickness: 100 mm
Other - Family: NLRS_57_AIR_UN_steel wheather wall louvre bmu intake LT_sacs; Family and Type: NLRS_57_AIR_UN_steel wheather wall louvre bmu intake LT_sacs: BMUDSQ; Type: BMUDSQ; Type Id: 1658577
Phasing - Phase Created: New Construction
Visibility - SACS_Show_Arrow: yes; SACS_Warning_Disabled: no
